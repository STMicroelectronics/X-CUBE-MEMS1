<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LIS2DW12_6DOrientation.ewp</path>
  </project>
  <batchBuild />
</workspace>

# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RE_NUCLEO +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STM32F401RE_NUCLEO\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F401xE,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\IKS01A2;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\asm330lhh;..\..\..\..\..\..\Drivers\BSP\Components\lps33hw;..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc;..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\..\..\..\Drivers\BSP\Components\ism303dac;..\..\..\..\..\..\Drivers\BSP\Components\ism330dlc;..\..\..\..\..\..\Drivers\BSP\Components\lis2dh12;..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox;..\..\..\..\..\..\Drivers\BSP\Components\ais2dw12;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsr;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\stts22h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhh/: asm330lhh.c asm330lhh_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/ism303dac/: ism303dac.c ism303dac_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dh12/: lis2dh12.c lis2dh12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lps33hw/: lps33hw.c lps33hw_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../../Drivers/BSP/Components/ais2dw12/: ais2dw12.c ais2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsr/: lsm6dsr.c lsm6dsr_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_env_sensors.c iks01a2_env_sensors_ex.c iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: cube_hal_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c com.c demo_serial.c sensor_commands.c serial_protocol.c nucleo_f401re_bus.c

# IAR project Project.ewp, settings and files
configuration STM32F401RE_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\ais2ih; ..\..\..\..\..\..\Drivers\BSP\Components\asm330lhhx; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dulpx; ..\..\..\..\..\..\Drivers\BSP\Components\iis2iclx; ..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\..\..\..\Drivers\BSP\Components\ilps22qs; ..\..\..\..\..\..\Drivers\BSP\Components\ism330bx; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\..\Drivers\BSP\Components\ism330is; ..\..\..\..\..\..\Drivers\BSP\Components\ism6hg256x; ..\..\..\..\..\..\Drivers\BSP\Components\sht40ad1b; ..\..\..\..\..\..\Drivers\BSP\IKS5A1; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DataLogExtended.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ais2ih/: ais2ih.c ais2ih_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhhx/: asm330lhhx.c asm330lhhx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dulpx/: iis2dulpx.c iis2dulpx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx.c iis2iclx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/ism330bx/: ism330bx.c ism330bx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330is/: ism330is.c ism330is_reg.c
    ../../../../../../Drivers/BSP/Components/ism6hg256x/: ism6hg256x.c ism6hg256x_reg.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b.c sht40ad1b_reg.c
  group Drivers/BSP/IKS5A1
    ../../../../../../Drivers/BSP/IKS5A1/: iks5a1_env_sensors.c iks5a1_env_sensors_ex.c iks5a1_motion_sensors.c iks5a1_motion_sensors_ex.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: com.c cube_hal_f4.c demo_serial.c main.c nucleo_f401re_bus.c sensor_commands.c serial_protocol.c stm32f4xx_hal_msp.c stm32f4xx_it.c

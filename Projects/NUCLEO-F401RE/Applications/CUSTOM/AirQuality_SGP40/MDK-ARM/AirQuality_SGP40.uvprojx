# Keil uVision project AirQuality_SGP40.uvprojx, settings and files
target AirQuality_SGP40 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AirQuality_SGP40 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/sht40ad1b;../../../../../../Drivers/BSP/Components/lps22df;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/Sensirion/sensirion_gas_index_algorithm;../../../../../../Drivers/BSP/Components/sgp40
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c custom_env_sensors.c custom_env_sensors_ex.c com.c demo_serial.c serial_protocol.c custom_mems_control.c custom_mems_control_ex.c env_aq_manager.c app_mems.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b_reg.c sht40ad1b.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df.c
    ../../../../../../Drivers/BSP/Components/sgp40/: sgp40_reg.c sgp40.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_EnvAQ_Library/Core
    ../../../../../../Middlewares/Third_Party/Sensirion/sensirion_gas_index_algorithm/: sensirion_gas_index_algorithm.c
software components: CMSIS:CORE 4.3.0

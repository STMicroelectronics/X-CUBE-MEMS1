# IAR project Project.ewp, settings and files
configuration STM32L152RE_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_HAL_DRIVER; USE_STM32L1XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\IKS4A1; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\asm330lhh; ..\..\..\..\..\..\Drivers\BSP\Components\asm330lhhx; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc; ..\..\..\..\..\..\Drivers\BSP\Components\iis2iclx; ..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\..\..\..\Drivers\BSP\Components\ism303dac; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dlc; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dh12; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\..\Drivers\BSP\Components\lps22ch; ..\..\..\..\..\..\Drivers\BSP\Components\lps27hhtw; ..\..\..\..\..\..\Drivers\BSP\Components\lps33hw; ..\..\..\..\..\..\Drivers\BSP\Components\lps33k; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox; ..\..\..\..\..\..\Drivers\BSP\Components\stts751; ..\..\..\..\..\..\Drivers\BSP\Components\ais2dw12; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsr; ..\..\..\..\..\..\Drivers\BSP\Components\stts22h; ..\..\..\..\..\..\Drivers\BSP\Components\a3g4250d; ..\..\..\..\..\..\Drivers\BSP\Components\ais328dq; ..\..\..\..\..\..\Drivers\BSP\Components\ais3624dq; ..\..\..\..\..\..\Drivers\BSP\Components\h3lis331dl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsrx; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso32; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso16is; ..\..\..\..\..\..\Drivers\BSP\Components\ais2ih; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso32x; ..\..\..\..\..\..\Drivers\BSP\Components\lps22df; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dtw12; ..\..\..\..\..\..\Drivers\BSP\Components\lis2du12; ..\..\..\..\..\..\Drivers\BSP\Components\ilps22qs; ..\..\..\..\..\..\Drivers\BSP\Components\ilps28qsw; ..\..\..\..\..\..\Drivers\BSP\Components\lps28dfw; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv16x; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv16bx; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv16b; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dux12; ..\..\..\..\..\..\Drivers\BSP\Components\lis2duxs12; ..\..\..\..\..\..\Drivers\BSP\Components\sht40ad1b; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv32x; ..\..\..\..\..\..\Drivers\BSP\Components\ism330bx; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv80x; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsv320x; ..\..\..\..\..\..\Drivers\BSP\Components\st1vafe3bx; ..\..\..\..\..\..\Drivers\BSP\Components\st1vafe6ax
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DataLogExtended.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/a3g4250d/: a3g4250d.c a3g4250d_reg.c
    ../../../../../../Drivers/BSP/Components/ais2dw12/: ais2dw12.c ais2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/ais2ih/: ais2ih.c ais2ih_reg.c
    ../../../../../../Drivers/BSP/Components/ais328dq/: ais328dq.c ais328dq_reg.c
    ../../../../../../Drivers/BSP/Components/ais3624dq/: ais3624dq.c ais3624dq_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhh/: asm330lhh.c asm330lhh_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhhx/: asm330lhhx.c asm330lhhx_reg.c
    ../../../../../../Drivers/BSP/Components/h3lis331dl/: h3lis331dl.c h3lis331dl_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx.c iis2iclx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/ilps28qsw/: ilps28qsw.c ilps28qsw_reg.c
    ../../../../../../Drivers/BSP/Components/ism303dac/: ism303dac.c ism303dac_reg.c
    ../../../../../../Drivers/BSP/Components/ism330bx/: ism330bx.c ism330bx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dh12/: lis2dh12.c lis2dh12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dtw12/: lis2dtw12.c lis2dtw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2du12/: lis2du12.c lis2du12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dux12/: lis2dux12.c lis2dux12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12.c lis2duxs12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22ch/: lps22ch.c lps22ch_reg.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lps27hhtw/: lps27hhtw.c lps27hhtw_reg.c
    ../../../../../../Drivers/BSP/Components/lps28dfw/: lps28dfw.c lps28dfw_reg.c
    ../../../../../../Drivers/BSP/Components/lps33hw/: lps33hw.c lps33hw_reg.c
    ../../../../../../Drivers/BSP/Components/lps33k/: lps33k.c lps33k_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is.c lsm6dso16is_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso32/: lsm6dso32.c lsm6dso32_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso32x/: lsm6dso32x.c lsm6dso32x_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsr/: lsm6dsr.c lsm6dsr_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsrx/: lsm6dsrx.c lsm6dsrx_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv/: lsm6dsv.c lsm6dsv_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv16b/: lsm6dsv16b.c lsm6dsv16b_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv16bx/: lsm6dsv16bx.c lsm6dsv16bx_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x.c lsm6dsv16x_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv320x/: lsm6dsv320x.c lsm6dsv320x_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv32x/: lsm6dsv32x.c lsm6dsv32x_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv80x/: lsm6dsv80x.c lsm6dsv80x_reg.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b.c sht40ad1b_reg.c
    ../../../../../../Drivers/BSP/Components/st1vafe3bx/: st1vafe3bx.c st1vafe3bx_reg.c
    ../../../../../../Drivers/BSP/Components/st1vafe6ax/: st1vafe6ax.c st1vafe6ax_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS4A1
    ../../../../../../Drivers/BSP/IKS4A1/: iks4a1_env_sensors.c iks4a1_env_sensors_ex.c iks4a1_hybrid_sensors.c iks4a1_hybrid_sensors_ex.c iks4a1_motion_sensors.c iks4a1_motion_sensors_ex.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../Src/: com.c cube_hal_l1.c demo_serial.c main.c nucleo_l152re_bus.c sensor_commands.c serial_protocol.c stm32l1xx_hal_msp.c stm32l1xx_it.c

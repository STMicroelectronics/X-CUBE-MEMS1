# Keil uVision project Project.uvprojx, settings and files
target STM32L152RE_NUCLEO (6190000::V6.19::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32L152xE,USE_HAL_DRIVER,USE_STM32L1XX_NUCLEO
  c include: ../Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/ais2ih;../../../../../../Drivers/BSP/Components/asm330lhhx;../../../../../../Drivers/BSP/Components/iis2dlpc;../../../../../../Drivers/BSP/Components/iis2dulpx;../../../../../../Drivers/BSP/Components/iis2iclx;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/Components/ilps22qs;../../../../../../Drivers/BSP/Components/ism330bx;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/Components/ism330is;../../../../../../Drivers/BSP/Components/ism6hg256x;../../../../../../Drivers/BSP/Components/sht40ad1b;../../../../../../Drivers/BSP/IKS5A1;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ais2ih/: ais2ih.c ais2ih_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhhx/: asm330lhhx.c asm330lhhx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dulpx/: iis2dulpx.c iis2dulpx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx.c iis2iclx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../../../../Drivers/BSP/Components/ism330bx/: ism330bx.c ism330bx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330is/: ism330is.c ism330is_reg.c
    ../../../../../../Drivers/BSP/Components/ism6hg256x/: ism6hg256x.c ism6hg256x_reg.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b.c sht40ad1b_reg.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/IKS5A1
    ../../../../../../Drivers/BSP/IKS5A1/: iks5a1_env_sensors.c iks5a1_env_sensors_ex.c iks5a1_motion_sensors.c iks5a1_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_spi.c
  group Example/MDK-ARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../Src/: cube_hal_l1.c main.c stm32l1xx_hal_msp.c stm32l1xx_it.c com.c demo_serial.c sensor_commands.c serial_protocol.c nucleo_l152re_bus.c

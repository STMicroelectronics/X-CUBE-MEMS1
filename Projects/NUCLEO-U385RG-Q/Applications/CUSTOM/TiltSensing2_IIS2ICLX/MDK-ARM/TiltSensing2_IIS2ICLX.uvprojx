# Keil uVision project TiltSensing2_IIS2ICLX.uvprojx, settings and files
target TiltSensing2_IIS2ICLX (6140001::V6.14.1::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TiltSensing2_IIS2ICLX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_MotionAC2_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionTL2_Library/Inc;../../../../../../Drivers/BSP/Components/iis2iclx;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../Src/: main.c custom_motion_sensors.c custom_motion_sensors_ex.c com.c demo_serial.c serial_protocol.c custom_mems_control.c custom_mems_control_ex.c motion_ac2_manager.c motion_tl2_manager.c app_mems.c stm32u3xx_nucleo_bus.c stm32u3xx_nucleo.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx_reg.c iis2iclx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionAC2_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionAC2_Library/Lib/: MotionAC2_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionTL2_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionTL2_Library/Lib/: MotionTL2_CM33F_wc16_ot.a
software components: CMSIS:CORE 6.1.0

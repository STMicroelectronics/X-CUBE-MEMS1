# IAR project HighGLowGFusion_LSM6DSV320X.ewp, settings and files
configuration HighGLowGFusion_LSM6DSV320X (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385RG ST STM32U385RG
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U385xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/lsm6dsv320x; ../../../../../../Middlewares/ST/STM32_MotionXLF_Library/Inc; ../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HighGLowGFusion_LSM6DSV320X.hex
  ILINK.IlinkOutputFile: HighGLowGFusion_LSM6DSV320X.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  group Application/EWARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../Src/: main.c custom_motion_sensors.c custom_motion_sensors_ex.c com.c demo_serial.c serial_protocol.c custom_mems_control.c custom_mems_control_ex.c motion_xlf_manager.c app_mems.c stm32u3xx_nucleo_bus.c stm32u3xx_nucleo.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsv320x/: lsm6dsv320x_reg.c lsm6dsv320x.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionXLF_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionXLF_Library/Lib/: MotionXLF_CM33F_wc32_ot_hard.a

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AccelCalibration2_IIS2ICLX.ewp</path>
  </project>
  <batchBuild />
</workspace>

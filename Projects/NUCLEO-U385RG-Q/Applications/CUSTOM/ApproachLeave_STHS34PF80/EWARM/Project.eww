<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ApproachLeave_STHS34PF80.ewp</path>
  </project>
  <batchBuild />
</workspace>

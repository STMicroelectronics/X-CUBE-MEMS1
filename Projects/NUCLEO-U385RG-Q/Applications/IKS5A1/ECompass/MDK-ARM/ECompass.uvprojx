# Keil uVision project ECompass.uvprojx, settings and files
target ECompass (6140001::V6.14.1::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: ECompass +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U385xx
  c include: ../Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc;../../../../../../Drivers/BSP/Components/ism330is;../../../../../../Drivers/BSP/Components/ism6hg256x;../../../../../../Drivers/BSP/Components/ilps22qs;../../../../../../Drivers/BSP/Components/iis2dulpx;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/IKS5A1;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Application/User
    ../Src/: main.c com.c demo_serial.c serial_protocol.c iks5a1_mems_control.c iks5a1_mems_control_ex.c motion_mc_manager.c motion_ec_manager.c app_mems.c stm32u3xx_nucleo_bus.c stm32u3xx_nucleo.c stm32u3xx_it.c stm32u3xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330is/: ism330is_reg.c ism330is.c
    ../../../../../../Drivers/BSP/Components/ism6hg256x/: ism6hg256x_reg.c ism6hg256x.c
    ../../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs_reg.c ilps22qs.c
    ../../../../../../Drivers/BSP/Components/iis2dulpx/: iis2dulpx_reg.c iis2dulpx.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c iis2mdc.c
  group Drivers/BSP/IKS5A1
    ../../../../../../Drivers/BSP/IKS5A1/: iks5a1_motion_sensors.c iks5a1_motion_sensors_ex.c iks5a1_env_sensors.c iks5a1_env_sensors_ex.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_exti.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionMC_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM33F_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionEC_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM33F_wc16_ot.a
software components: CMSIS:CORE 6.1.0

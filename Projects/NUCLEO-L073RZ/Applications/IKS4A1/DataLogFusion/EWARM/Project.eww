<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DataLogFusion.ewp</path>
  </project>
  <batchBuild />
</workspace>

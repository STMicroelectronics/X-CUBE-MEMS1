# IAR project ECompass.ewp, settings and files
configuration ECompass (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 5
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/lsm6dsl; ../../../../../../Drivers/BSP/Components/lsm303agr; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/IKS01A2; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc; ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ECompass.hex
  ILINK.IlinkOutputFile: ECompass.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c com.c demo_serial.c serial_protocol.c iks01a2_mems_control.c iks01a2_mems_control_ex.c motion_mc_manager.c motion_ec_manager.c app_mems.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl_reg.c lsm6dsl.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr_reg.c lsm303agr.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb_reg.c lps22hb.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c iks01a2_env_sensors.c iks01a2_env_sensors_ex.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionMC_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM0P_wc32_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionEC_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM0P_wc32_ot.a

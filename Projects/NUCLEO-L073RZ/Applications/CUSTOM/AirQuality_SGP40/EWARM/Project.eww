<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AirQuality_SGP40.ewp</path>
  </project>
  <batchBuild />
</workspace>

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HighGLowGFusion_LSM6DSV320X.ewp</path>
  </project>
  <batchBuild />
</workspace>

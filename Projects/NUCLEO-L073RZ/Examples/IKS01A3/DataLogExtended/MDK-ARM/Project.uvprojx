# Keil uVision project Project.uvprojx, settings and files
target STM32L073RZ_NUCLEO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L073RZ_NUCLEO +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STM32L073RZ_NUCLEO\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_HAL_DRIVER,USE_STM32L0XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\IKS01A3;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\..\..\..\Drivers\BSP\Components\lps22ch;..\..\..\..\..\..\Drivers\BSP\Components\lps27hhtw;..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\..\..\..\Drivers\BSP\Components\stts751;..\..\..\..\..\..\Drivers\BSP\Components\lps33hw;..\..\..\..\..\..\Drivers\BSP\Components\asm330lhh;..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc;..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\..\..\..\Drivers\BSP\Components\ism303dac;..\..\..\..\..\..\Drivers\BSP\Components\ism330dlc;..\..\..\..\..\..\Drivers\BSP\Components\lis2dh12;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox;..\..\..\..\..\..\Drivers\BSP\Components\ais2dw12;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsr;..\..\..\..\..\..\Drivers\BSP\Components\stts22h;..\..\..\..\..\..\Drivers\BSP\Components\a3g4250d;..\..\..\..\..\..\Drivers\BSP\Components\ais328dq;..\..\..\..\..\..\Drivers\BSP\Components\ais3624dq;..\..\..\..\..\..\Drivers\BSP\Components\h3lis331dl;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsrx;..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso32;..\..\..\..\..\..\Drivers\BSP\Components\iis2iclx;..\..\..\..\..\..\Drivers\BSP\Components\lps33k;..\..\..\..\..\..\Drivers\BSP\Components\ais2ih;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso32x;..\..\..\..\..\..\Drivers\BSP\Components\lis2dtw12;..\..\..\..\..\..\Drivers\BSP\Components\lps22df
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
    ../../../../../../Drivers/BSP/Components/lps33hw/: lps33hw.c lps33hw_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhh/: asm330lhh.c asm330lhh_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ism303dac/: ism303dac.c ism303dac_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dh12/: lis2dh12.c lis2dh12_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../../Drivers/BSP/Components/ais2dw12/: ais2dw12.c ais2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsr/: lsm6dsr.c lsm6dsr_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
    ../../../../../../Drivers/BSP/Components/a3g4250d/: a3g4250d.c a3g4250d_reg.c
    ../../../../../../Drivers/BSP/Components/ais328dq/: ais328dq.c ais328dq_reg.c
    ../../../../../../Drivers/BSP/Components/ais3624dq/: ais3624dq.c ais3624dq_reg.c
    ../../../../../../Drivers/BSP/Components/h3lis331dl/: h3lis331dl.c h3lis331dl_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsrx/: lsm6dsrx.c lsm6dsrx_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso32/: lsm6dso32.c lsm6dso32_reg.c
    ../../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx.c iis2iclx_reg.c
    ../../../../../../Drivers/BSP/Components/lps33k/: lps33k.c lps33k_reg.c
    ../../../../../../Drivers/BSP/Components/lps22ch/: lps22ch.c lps22ch_reg.c
    ../../../../../../Drivers/BSP/Components/lps27hhtw/: lps27hhtw.c lps27hhtw_reg.c
    ../../../../../../Drivers/BSP/Components/ais2ih/: ais2ih.c ais2ih_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso32x/: lsm6dso32x.c lsm6dso32x_reg.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dtw12/: lis2dtw12.c lis2dtw12_reg.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_hybrid_sensors.c iks01a3_hybrid_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Example/User
    ../Src/: cube_hal_l0.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c com.c demo_serial.c sensor_commands.c serial_protocol.c nucleo_l073rz_bus.c

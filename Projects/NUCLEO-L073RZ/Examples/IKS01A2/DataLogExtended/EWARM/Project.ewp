# IAR project Project.ewp, settings and files
configuration STM32L073RZ_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L073xx; USE_HAL_DRIVER; USE_STM32L0XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\IKS01A2; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\Components\asm330lhh; ..\..\..\..\..\..\Drivers\BSP\Components\lps33hw; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc; ..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\..\Drivers\BSP\Components\ism303dac; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dlc; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dh12; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox; ..\..\..\..\..\..\Drivers\BSP\Components\ais2dw12; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsr; ..\..\..\..\..\..\Drivers\BSP\Components\stts22h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ais2dw12/: ais2dw12.c ais2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhh/: asm330lhh.c asm330lhh_reg.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ism303dac/: ism303dac.c ism303dac_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dh12/: lis2dh12.c lis2dh12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lps33hw/: lps33hw.c lps33hw_reg.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsr/: lsm6dsr.c lsm6dsr_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_env_sensors.c iks01a2_env_sensors_ex.c iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Examples/EWARM
    ./: startup_stm32l073xx.s
  group Examples/User
    ../Src/: com.c cube_hal_l0.c demo_serial.c main.c nucleo_l073rz_bus.c sensor_commands.c serial_protocol.c stm32l0xx_hal_msp.c stm32l0xx_it.c

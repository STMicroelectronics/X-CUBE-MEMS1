<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LSM6DSO_FIFOMode.ewp</path>
  </project>
  <batchBuild />
</workspace>

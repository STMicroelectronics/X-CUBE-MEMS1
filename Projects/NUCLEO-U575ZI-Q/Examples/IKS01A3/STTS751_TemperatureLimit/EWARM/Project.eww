<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STTS751_TemperatureLimit.ewp</path>
  </project>
  <batchBuild />
</workspace>

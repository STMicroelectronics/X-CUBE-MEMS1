# Keil uVision project Project.uvprojx, settings and files
target STM32U575ZI_Q_NUCLEO (6190000::V6.19::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: STM32U575ZI_Q_NUCLEO +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=.\STM32U575ZI_Q_NUCLEO\Objects\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: STM32U575xx,USE_HAL_DRIVER,USE_STM32U5XX_NUCLEO
  c include: ../Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/asm330lhhx;../../../../../../Drivers/BSP/Components/iis2dlpc;../../../../../../Drivers/BSP/Components/iis2dulpx;../../../../../../Drivers/BSP/Components/iis2iclx;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/Components/sht40ad1b;..\..\..\..\..\..\Drivers\BSP\Components\ism330bx;../../../../../../Drivers/BSP/IKS02A1;../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dulpx/: iis2dulpx.c iis2dulpx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ism330bx/: ism330bx.c ism330bx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx.c iis2iclx_reg.c
    ../../../../../../Drivers/BSP/Components/asm330lhhx/: asm330lhhx.c asm330lhhx_reg.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b.c sht40ad1b_reg.c
  group Drivers/BSP/IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c iks02a1_env_sensors.c iks02a1_env_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32u575xx.s
  group Example/User
    ../Src/: com.c cube_hal_u5.c demo_serial.c main.c sensor_commands.c serial_protocol.c stm32u5xx_hal_msp.c stm32u5xx_it.c stm32u5xx_nucleo.c stm32u5xx_nucleo_bus.c
software components: CMSIS:CORE 5.4.0

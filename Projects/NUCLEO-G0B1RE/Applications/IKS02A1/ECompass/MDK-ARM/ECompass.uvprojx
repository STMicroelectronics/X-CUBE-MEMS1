# Keil uVision project ECompass.uvprojx, settings and files
target ECompass (ARM-ADS)
  device: STM32G0B1RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: ECompass +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Inc;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/iis2dlpc;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/IKS02A1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc;../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User
    ../Src/: main.c com.c demo_serial.c serial_protocol.c iks02a1_mems_control.c iks02a1_mems_control_ex.c motion_mc_manager.c motion_ec_manager.c app_mems.c stm32g0xx_nucleo_bus.c stm32g0xx_nucleo.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c iis2dlpc.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c iis2mdc.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c ism330dhcx.c
  group Drivers/BSP/IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionMC_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM0P_wc16_ot.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionEC_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM0P_wc16_ot.a
software components: CMSIS:CORE 4.3.0

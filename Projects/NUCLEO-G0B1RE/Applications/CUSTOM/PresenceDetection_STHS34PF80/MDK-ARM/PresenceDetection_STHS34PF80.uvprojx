# Keil uVision project PresenceDetection_STHS34PF80.uvprojx, settings and files
target PresenceDetection_STHS34PF80 (ARM-ADS)
  device: STM32G0B1RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: PresenceDetection_STHS34PF80 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Inc;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_InfraredPD_Library/Inc;../../../../../../Drivers/BSP/Components/sths34pf80;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User
    ../Src/: main.c custom_env_sensors.c custom_env_sensors_ex.c com.c demo_serial.c serial_protocol.c custom_mems_control.c custom_mems_control_ex.c infrared_pd_manager.c app_mems.c stm32g0xx_nucleo_bus.c stm32g0xx_nucleo.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sths34pf80/: sths34pf80_reg.c sths34pf80.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_InfraredPD_Library/Core
    ../../../../../../Middlewares/ST/STM32_InfraredPD_Library/Lib/: InfraredPD_CM0P_wc16_ot.a
software components: CMSIS:CORE 4.3.0

# IAR project PedometerWrist.ewp, settings and files
configuration PedometerWrist (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_MotionPW_Library/Inc; ../../../../../../Drivers/BSP/Components/lsm6dso; ../../../../../../Drivers/BSP/Components/lis2dw12; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hh; ../../../../../../Drivers/BSP/Components/stts751; ../../../../../../Drivers/BSP/IKS01A3; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/STM32_MotionAW_Library/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PedometerWrist.hex
  ILINK.IlinkOutputFile: PedometerWrist.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c com.c demo_serial.c serial_protocol.c iks01a3_mems_control.c iks01a3_mems_control_ex.c motion_aw_manager.c motion_pw_manager.c app_mems.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso_reg.c lsm6dso.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c lis2dw12.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c lps22hh.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751_reg.c stts751.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_env_sensors.c iks01a3_env_sensors_ex.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionPW_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc32_ot_hard.a
  group Middlewares/X-CUBE-MEMS1/Sensors/STM32_MotionAW_Library/Core
    ../../../../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc32_ot_hard.a

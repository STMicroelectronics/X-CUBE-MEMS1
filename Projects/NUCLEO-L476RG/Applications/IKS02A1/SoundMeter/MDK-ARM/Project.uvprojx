# Keil uVision project Project.uvprojx, settings and files
target IMP34DT05_SoundMeter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IROM(0x08004000-0x80FFFFF) IROM(0x08000000-0x8003FFF) IRAM(0x20000200-0x20017DFF) IRAM(0x20000000-0x1FFFFFFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,ARM_MATH_CM4,USE_IKS02A1
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../../Drivers/BSP/IKS02A1;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Audio/Addons/Common/Inc;../../../../../../Middlewares/ST/STM32_Audio/Addons/SMR/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: audio_application.c cube_hal_l4.c main.c stm32xx_it.c com.c DemoSerial.c serial_protocol.c stm32l4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_audio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/ST/STM32_Audio/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/ST/STM32_Audio/SMR
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/SMR/Lib/: SMR_CM4_Keil.lib
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
